.title KiCad schematic
.include "spice_lib/MMSZ5231B.lib"
UU3 /-1 /-3 Net-_U3-Pad3_ /-4 /-2 Net-_U2-Pad4_ GNDA GNDA /CB /CA /+4 /+1 Net-_U3-Pad13_ /+2 /+3 +5VA CD4052B
UU4 /-5 /-7 Net-_U3-Pad3_ /-8 /-6 Net-_U2-Pad5_ GNDA GNDA /CB /CA /+8 /+5 Net-_U3-Pad13_ /+6 /+7 +5VA CD4052B
UU5 /-9 /-11 Net-_U3-Pad3_ /-12 /-10 Net-_U2-Pad6_ GNDA GNDA /CB /CA /+12 /+9 Net-_U3-Pad13_ /+10 /+11 +5VA CD4052B
UU6 /-13 /-15 Net-_U3-Pad3_ /-16 /-14 Net-_U2-Pad7_ GNDA GNDA /CB /CA /+16 /+13 Net-_U3-Pad13_ /+14 /+15 +5VA CD4052B
UU2 Net-_J3-Pad2_ /DA /DB Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ GNDA +5VA 4556
UU7 Net-_R7-Pad1_ Net-_U3-Pad3_ Net-_U3-Pad13_ GNDA GNDA Net-_J4-Pad1_ +5VA Net-_R7-Pad2_ AD623
CC15 +5VA GNDA 0.1u
CC16 +5VA GNDA 10u
CC10 +5VA GNDA 0.1u
CC14 +5VA GNDA 10u
CC8 +5VA GNDA 0.1u
CC12 +5VA GNDA 10u
CC9 +5VA GNDA 0.1u
CC13 +5VA GNDA 10u
CC7 +5VA GNDA 0.1u
CC11 +5VA GNDA 10u
CC5 +5VA GNDA 0.1u
CC6 +5VA GNDA 10u
UU8 +5VA Net-_C17-Pad1_ GNDA GNDA GND GND Net-_J4-Pad3_ +5V ACPL-790x
RR8 Net-_C17-Pad1_ Net-_J4-Pad1_ 10
CC17 Net-_C17-Pad1_ GNDA 22n
CC18 +5VA GNDA 0.1u
CC19 GND +5V 0.1u
RR2 +5VA /DMUX_EN 4.7K
RR5 /CB GNDA 4.7K
RR6 /CA GNDA 4.7K
RR1 /DB GNDA 4.7K
RR4 /DA GNDA 4.7K
RR27 Net-_Q1-Pad1_ /IN2 150
RR28 Net-_Q1-Pad1_ GNDA 100K
RR30 /+2 /-2 15K
RR29 /F2 /+2 39K
MQ1 Net-_Q1-Pad1_ GNDA /-2 IRL620
XD2 /+2 GNDA DI_MMSZ5231B
VV1 /F2 GNDA 200V
RR33 Net-_Q2-Pad1_ /IN4 150
RR34 Net-_Q2-Pad1_ GNDA 100K
RR36 /+4 /-4 15K
RR35 /F4 /+4 39K
MQ2 Net-_Q2-Pad1_ GNDA /-4 IRL620
XD3 /+4 GNDA DI_MMSZ5231B
VV2 /F4 GNDA 200V
RR39 Net-_Q3-Pad1_ /IN6 150
RR40 Net-_Q3-Pad1_ GNDA 100K
RR42 /+6 /-6 15K
RR41 /F6 /+6 39K
MQ3 Net-_Q3-Pad1_ GNDA /-6 IRL620
XD4 /+6 GNDA DI_MMSZ5231B
VV3 /F6 GNDA 200V
RR45 Net-_Q4-Pad1_ /IN8 150
RR46 Net-_Q4-Pad1_ GNDA 100K
RR48 /+8 /-8 15K
RR47 /F8 /+8 39K
MQ4 Net-_Q4-Pad1_ GNDA /-8 IRL620
XD5 /+8 GNDA DI_MMSZ5231B
VV4 /F8 GNDA 200V
RR51 Net-_Q5-Pad1_ /IN10 150
RR52 Net-_Q5-Pad1_ GNDA 100K
RR54 /+10 /-10 15K
RR53 /F10 /+10 39K
MQ5 Net-_Q5-Pad1_ GNDA /-10 IRL620
XD6 /+10 GNDA DI_MMSZ5231B
VV5 /F10 GNDA 200V
RR57 Net-_Q6-Pad1_ /IN16 150
RR58 Net-_Q6-Pad1_ GNDA 100K
RR60 /+16 /-16 15K
RR59 /F16 /+16 39K
MQ6 Net-_Q6-Pad1_ GNDA /-16 IRL620
XD8 /+16 GNDA DI_MMSZ5231B
VV6 /F16 GNDA 200V
RR63 Net-_Q7-Pad1_ /IN3 150
RR64 Net-_Q7-Pad1_ GNDA 100K
RR66 /+3 /-3 15K
RR65 /F3 /+3 39K
MQ7 Net-_Q7-Pad1_ GNDA /-3 IRL620
XD9 /+3 GNDA DI_MMSZ5231B
VV7 /F3 GNDA 200V
RR69 Net-_Q8-Pad1_ /IN5 150
RR70 Net-_Q8-Pad1_ GNDA 100K
RR72 /+5 /-5 15K
RR71 /F5 /+5 39K
MQ8 Net-_Q8-Pad1_ GNDA /-5 IRL620
XD10 /+5 GNDA DI_MMSZ5231B
VV8 /F5 GNDA 200V
RR75 Net-_Q9-Pad1_ /IN7 150
RR76 Net-_Q9-Pad1_ GNDA 100K
RR78 /+7 /-7 15K
RR77 /F7 /+7 39K
MQ9 Net-_Q9-Pad1_ GNDA /-7 IRL620
XD11 /+7 GNDA DI_MMSZ5231B
VV9 /F7 GNDA 200V
RR81 Net-_Q10-Pad1_ /IN9 150
RR82 Net-_Q10-Pad1_ GNDA 100K
RR84 /+9 /-9 15K
RR83 /F9 /+9 39K
MQ10 Net-_Q10-Pad1_ GNDA /-9 IRL620
XD12 /+9 GNDA DI_MMSZ5231B
VV10 /F9 GNDA 200V
RR87 Net-_Q11-Pad1_ /IN11 150
RR88 Net-_Q11-Pad1_ GNDA 100K
RR90 /+11 /-11 15K
RR89 /F11 /+11 39K
MQ11 Net-_Q11-Pad1_ GNDA /-11 IRL620
XD14 /+11 GNDA DI_MMSZ5231B
VV11 /F11 GNDA 200V
RR93 Net-_Q12-Pad1_ /IN13 150
RR94 Net-_Q12-Pad1_ GNDA 100K
RR96 /+13 /-13 15K
RR95 /F13 /+13 39K
MQ12 Net-_Q12-Pad1_ GNDA /-13 IRL620
XD15 /+13 GNDA DI_MMSZ5231B
VV12 /F13 GNDA 200V
RR99 Net-_Q13-Pad1_ /IN15 150
RR100 Net-_Q13-Pad1_ GNDA 100K
RR102 /+15 /-15 15K
RR101 /F15 /+15 39K
MQ13 Net-_Q13-Pad1_ GNDA /-15 IRL620
XD16 /+15 GNDA DI_MMSZ5231B
VV13 /F15 GNDA 200V
RR105 Net-_Q14-Pad1_ /IN1 150
RR106 Net-_Q14-Pad1_ GNDA 100K
RR108 /+1 /-1 15K
RR107 /F1 /+1 39K
MQ14 Net-_Q14-Pad1_ GNDA /-1 IRL620
XD17 /+1 GNDA DI_MMSZ5231B
VV14 /F1 GNDA 200V
RR111 Net-_Q15-Pad1_ /IN14 150
RR112 Net-_Q15-Pad1_ GNDA 100K
RR114 /+14 /-14 15K
RR113 /F14 /+14 39K
MQ15 Net-_Q15-Pad1_ GNDA /-14 IRL620
XD18 /+14 GNDA DI_MMSZ5231B
VV15 /F14 GNDA 200V
RR117 Net-_Q16-Pad1_ /IN12 150
RR118 Net-_Q16-Pad1_ GNDA 100K
RR120 /+12 /-12 15K
RR119 /F12 /+12 39K
MQ16 Net-_Q16-Pad1_ GNDA /-12 IRL620
XD20 /+12 GNDA DI_MMSZ5231B
VV16 /F12 GNDA 200V
CC21 +5VA GNDA 0.1u
CC20 +5VA GNDA 0.1u
CC22 +5VA GNDA 0.1u
RR11 /digital_input_isolation/optoisolator_with_peripherals_2/out_1 +5VA 4.7K
RR12 /digital_input_isolation/optoisolator_with_peripherals_2/out_1 +5VA 4.7K
RR13 +5VA /digital_input_isolation/optoisolator_with_peripherals_3/out_2 4.7K
RR9 +5VA /digital_input_isolation/optoisolator_with_peripherals_3/out_1 4.7K
RR15 Net-_R15-Pad1_ /4 220
RR16 Net-_R16-Pad1_ /5_**_ 220
CC23 +5VA GNDA 0.1u
RR18 +5VA /digital_input_isolation/optoisolator_with_peripherals_1/out_2 2.2K
RR17 +5VA /digital_input_isolation/optoisolator_with_peripherals_1/out_1 2.2K
RR19 Net-_R19-Pad1_ /6_**_ 220
RR20 Net-_R20-Pad1_ /7 220
CC24 +5VA GNDA 0.1u
RR22 +5VA /digital_input_isolation/optoisolator_with_peripherals_2/out_2 2.2K
RR21 +5VA /digital_input_isolation/optoisolator_with_peripherals_2/out_1 2.2K
RR23 Net-_R23-Pad1_ /8 220
RR24 Net-_R24-Pad1_ /9_**_ 220
CC25 +5VA GNDA 0.1u
RR26 +5VA /digital_input_isolation/optoisolator_with_peripherals_3/out_2 2.2K
RR25 +5VA /digital_input_isolation/optoisolator_with_peripherals_3/out_1 2.2K

.dc VV1 1V 200V 10V
.end
