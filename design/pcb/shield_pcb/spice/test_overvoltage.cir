.TITLE shield_pcb overvoltage protection DC analysis

* gives us a SUBCKT called DI_MMSZ5231B
* (1=A(node?) 2=K(athode?))
.include lib/MMSZ5231B.cir

* there does not seem be be a spice model available for the exact FETs I'm using
* and this was the closest I could find
* they are also not easily derived from the datasheets...
* provides irl530n w/ node order: D G S
* TODO check datasheet to see in which ways this differs from IRL620 / SiHL620
.include lib/sihl530.cir

* TODO use 120V at least... invoke this from python and use max_safe_voltage or
* whatever?
Vs 1 0 DC 100V

*******************************************************************************
* working approximation of flies actual resistance
*******************************************************************************
*Rfly 1 2 50000K
*******************************************************************************

*Rshort 1 2 0.001
Rfly 1 2 50000K

Rlim 2 3 39K

*******************************************************************************
* TODO the question now is:
* does the zener completely defeat the point of having a switch?
* (i.e. if the switch is off, is the fly still getting shocked?)
* i think the answer is no, if the fly resistance is not way lower than expected
* because it would take <<39KR upstream of Rlim to have Xzener turn on (get to
* >4.8V)

* i'm getting less sure... might be the below though?
*******************************************************************************

*******************************************************************************
* TODO TODO another big question:
* even without the Zener, does it matter if the FET is off if the flies
* resistance is so high? (if ""R""fet_off >> R_fly, then voltage across fly is
* small, but if R_fly ~> ""R""fet_off, then voltage across fly can be large even
* if off)

* is this somewhere where the model for this fet and irl620 diverge?
* or maybe the spice models don't work well in general?
* need more than DC analysis?
*******************************************************************************

* X is the prefix to address a subckt
* node 0 should be "GND" (negative terminal of power supply)
* TODO measure current through this diode
*Xzener 0 3 DI_MMSZ5231B

* also try 100K. others?
Rsense 3 4 150K

* TODO test with logic low and high
Vcc 5 0 DC 5V

* consider MOSFET both on and off
* node order is D, G, S, B (bulk substrate)
* TODO what to do with B?
* TODO mosfet parameters? most accurate model?
*M1 4 6 2 7 MOSN
Xfet 4 6 0 irl530n
Rgate 5 6 150
Rpulldown 6 0 100K

* calculate DC voltages at all nodes, fills v(n) vector?
.op

*TODO why are these not executed when loading circuit?
.print op v(1) v(2) v(3) v(5)

.end
